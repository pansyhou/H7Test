# Keil uVision project H7Test.uvprojx, settings and files
target H7Test (6190000::V6.19::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7Test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_LOOPUNROLL
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Bsp;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/ST/ARM/DSP/Inc;../Control/Inc;../Algorithm/inc;../Task/Inc;../platform;../platform/GCC/ARM_CM4F;../DSP/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Bsp
    ../Bsp/: bsp_dr16.c bsp_can.c bsp_Motor_Encoder.c bsp_pwm.c
  group Middlewares/FreeRTOS
    ../platform/GCC/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Control
    ../Control/Src/: SYSInit.c rmmotor.c RemoteDeal.c GimbalMotor.c BoardCommuni.c
  group Task
    ../Task/Src/: BoardCommuni_Task.c Detect_Task.c fsm.c Gimbal_Fsm.c Gimbal_Task.c Remote_Task.c
  group Algorithm
    ../Algorithm/src/: fifo.c filter.c maths.c pid.c
  group platform
    ../platform/: BoardConfig.h
  group CMSIS/DSP
    ../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../DSP/Source/BayesFunctions/: BayesFunctions.c
    ../DSP/Source/CommonTables/: CommonTables.c
    ../DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../DSP/Source/SupportFunctions/: SupportFunctions.c
    ../DSP/Source/SVMFunctions/: SVMFunctions.c
    ../DSP/Source/TransformFunctions/: TransformFunctions.c
software components: CMSIS:CORE 5.6.0
